# Keil uVision project N76E003Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E003Test +hex
  c flags: Optimize=9
  c define: FOSC_160000
  c include: .\Include
  group Sources
    ./: main.c
  group Startup
    ./: STARTUP.A51
  group Commons
    ./: i2c_handler.c TDS1307.c TSSD1306.c OneLineSymbols.c
    ./Common/: Common.c Delay.c
